# Keil uVision project slave.uvproj, settings and files
target Target 1 (MCS-51)
  device: EZ-USB 8051 AnchorChips
  cpu: IRAM(0 - 0xFF) CLOCK(25000000) MODDP2
  output: slave +hex
  AfterMake: C:\Cypress\USB\CY3684_EZ-USB_FX2LP_DVK\1.1\Bin\Hex2bix -i -f 0xC2 slave.iic slave.hex
  c flags: Optimize=6 SizeSpeed=1
  group Source Group 1
    ./: FW.C DSCR.A51 slave.c EZUSB.LIB USBJmpTb.OBJ Fx2.h fx2regs.h fx2sdly.h syncdly.h
